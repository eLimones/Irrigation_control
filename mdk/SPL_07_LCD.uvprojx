# Keil uVision project SPL_07_LCD.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F051K6 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SPL_07_LCD_STM32F0
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F051  USE_STDPERIPH_DRIVER
  c include: ..\include;..\retarget\include;..\STM32F0xx_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ../source/: LCD_stm32f0.c main.c LCD.c
  group SPl
    ../STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_cec.c stm32f0xx_comp.c stm32f0xx_crc.c stm32f0xx_crs.c stm32f0xx_dac.c stm32f0xx_dbgmcu.c stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_wwdg.c
  group retarget
    ../retarget/source/: retarget_STM32F0.c serial_stdio.c
software components: CMSIS:CORE 4.1.0, Device:Startup 1.5.0
